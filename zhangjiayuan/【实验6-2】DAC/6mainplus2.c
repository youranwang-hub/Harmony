#include "stm32f4xx.h"

/*
 * DAC输出值
 * 有效范围始终为0～4095
 */
u16 DacValue = 4095;

/*
 * 当前递减级数
 * 取值范围为0～17，共18个输出电压点
 */
u8 StepIndex = 0;

/* 定义所需结构体 */
GPIO_InitTypeDef GPIO_InitStructure;
DAC_InitTypeDef DAC_InitType;

/* 函数声明 */
void delay_us(uint16_t nus);
void delay_ms(u16 nms);

int main(void)
{
    /*
     * 使能GPIOA时钟
     */
    RCC_AHB1PeriphClockCmd(
        RCC_AHB1Periph_GPIOA,
        ENABLE
    );

    /*
     * 使能DAC时钟
     */
    RCC_APB1PeriphClockCmd(
        RCC_APB1Periph_DAC,
        ENABLE
    );

    /*
     * 配置PA4为模拟模式
     * PA4对应DAC通道1输出
     */
    GPIO_InitStructure.GPIO_Pin = GPIO_Pin_4;
    GPIO_InitStructure.GPIO_Mode = GPIO_Mode_AN;
    GPIO_InitStructure.GPIO_PuPd = GPIO_PuPd_NOPULL;

    GPIO_Init(
        GPIOA,
        &GPIO_InitStructure
    );

    /*
     * 配置DAC通道1
     */
    DAC_InitType.DAC_Trigger = DAC_Trigger_None;
    /* 不使用外部触发 */

    DAC_InitType.DAC_WaveGeneration =
        DAC_WaveGeneration_None;
    /* 不使用噪声波或三角波发生器 */

    DAC_InitType.DAC_LFSRUnmask_TriangleAmplitude =
        DAC_LFSRUnmask_Bit0;

    DAC_InitType.DAC_OutputBuffer =
        DAC_OutputBuffer_Enable;
    /*
     * 开启DAC输出缓存，提高PA4输出驱动能力，
     * 使万用表测量结果更加稳定
     */

    DAC_Init(
        DAC_Channel_1,
        &DAC_InitType
    );

    /*
     * 使能DAC通道1
     */
    DAC_Cmd(
        DAC_Channel_1,
        ENABLE
    );

    /*
     * 设置初始输出值为4095，
     * 对应接近3.3V
     */
    DAC_SetChannel1Data(
        DAC_Align_12b_R,
        DacValue
    );

    while (1)
    {
        /*
         * 根据当前递减级数直接计算DAC值
         *
         * StepIndex=0时：
         * DacValue=4095
         *
         * StepIndex=17时：
         * DacValue=0
         *
         * 使用32位计算，避免中间乘法产生溢出
         */
        DacValue =
            4095 -
            ((uint32_t)4095 * StepIndex / 17);

        /*
         * 输出DAC数值
         * 使用12位右对齐格式
         */
        DAC_SetChannel1Data(
            DAC_Align_12b_R,
            DacValue
        );

        /*
         * 当前电压保持1秒，
         * 便于万用表稳定显示
         */
        delay_ms(1000);

        /*
         * 进入下一个递减级别
         */
        StepIndex++;

        /*
         * 已经输出到第17级，即0V后，
         * 下一次重新从第0级开始
         */
        if (StepIndex > 17)
        {
            StepIndex = 0;
        }
    }
}

/***** 简单延时函数：ms、us *****/

void delay_us(uint16_t nus)
{
    uint16_t i;

    while (nus--)
    {
        i = 31;

        while (i--)
        {
        }
    }
}

void delay_ms(u16 nms)
{
    uint16_t i;

    while (nms--)
    {
        i = 33800;

        while (i--)
        {
        }
    }
}
