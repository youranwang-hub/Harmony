# Keil uVision project Project.uvprojx, settings and files
target STM32F407_Hazard_Monitor_System (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\USER;..\CORE;..\UTILS;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\SENSOR;..\HARDWARE\COMMUNICATION;..\HARDWARE\STORAGE;..\HARDWARE\MODULE;..\HARDWARE\CONTROL;..\HARDWARE\SIMULATION;..\HARDWARE\UI;..\REFERENCE_DRIVERS\LCD_ILI9341
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: app_main.c app_main.h app_types.h main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_config.h system_stm32f4xx.c system_stm32f4xx.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group UTILS
    ../UTILS/: delay.c delay.h utils.c utils.h
  group HARDWARE_LCD
    ../HARDWARE/LCD/: lcd.c lcd.h
    ../REFERENCE_DRIVERS/LCD_ILI9341/: lcd_fonts.c lcd_fonts.h lcd_ili9341.c lcd_ili9341.h
  group HARDWARE_TOUCH
    ../HARDWARE/TOUCH/: xpt2046.c xpt2046.h
  group SENSOR
    ../HARDWARE/SENSOR/: adc_sensor.c adc_sensor.h dac_output.c dac_output.h data_manager.c data_manager.h dht11.c dht11.h mq2.c mq2.h
  group COMMUNICATION
    ../HARDWARE/COMMUNICATION/: can_protocol.c can_protocol.h command_parser.c command_parser.h dma_uart.c dma_uart.h usart_debug.c usart_debug.h
  group STORAGE
    ../HARDWARE/STORAGE/: eeprom.c eeprom.h log_manager.c log_manager.h cargo_manager.c cargo_manager.h w25q64.c w25q64.h
  group MODULE
    ../HARDWARE/MODULE/: fingerprint.c fingerprint.h gps.c gps.h nfc.c nfc.h rtc_manager.c rtc_manager.h
  group CONTROL
    ../HARDWARE/CONTROL/: alarm.c alarm.h gpio_control.c gpio_control.h pwm_control.c pwm_control.h state_machine.c state_machine.h
  group SIMULATION
    ../HARDWARE/SIMULATION/: gas_scene.c gas_scene.h gps_replay.c gps_replay.h
  group UI
    ../HARDWARE/UI/: ui_alarm.c ui_main.c ui_main.h ui_scene.c ui_setting.c
